# IAR project at91sam7x-ek.ewp, settings and files
configuration at91sam7x256_flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91sam7x256 Atmel at91sam7x256
  ICCARM.CCDefines: at91sam7x256; flash; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\at91lib/boards/at91sam7x-ek; ..\..\at91lib/peripherals; $TOOLKIT_DIR$\INC\Atmel
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam7x256; flash; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam7x-ek
  OBJCOPY.OOCOutputFile: at91sam7x256_flash.bin
  ILINK.IlinkOutputFile: at91sam7x256_flash.out
  ILINK.IlinkIcfFile: ..\..\at91lib\boards\at91sam7x-ek\at91sam7x256\flash
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam7x256_sram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam7x256; sram; TRACE_LEVEL=4
  AARM.ADefines: at91sam7x256; sram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7x256_sram.bin
  ILINK.IlinkOutputFile: at91sam7x256_sram.out
  ILINK.IlinkIcfFile: ..\..\at91lib\boards\at91sam7x-ek\at91sam7x256\sram
  group at91lib/at91sam7x256
    ../../../at91lib/boards/at91sam7x-ek/at91sam7x256/: AT91SAM7X256.h chip.h flash.icf sram.icf
    ../../at91lib/boards/at91sam7x-ek/: board_cstartup_iar.s board_lowlevel.c board_memories.c
  group documentation
    $EW_DIR$/arm/examples/Atmel/: flashloaders.html
    $EW_DIR$/arm/examples/Atmel/documentation/: index.html
  group resources
    ../../../resources/iar/: at91sam7x-ek-flash.mac at91sam7x-ek-sram.mac
  group user
    ../: adc.c lcd.c main_all.c pwm.c sd_ll_spi1.c sd_spi_mode.c system.c test.c usart.c
